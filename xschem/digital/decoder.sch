v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {/w0} -310 -2820 0 0 0.2 0.2 {}
T {/w1} -280 -2820 0 0 0.2 0.2 {}
T {/w2} -250 -2820 0 0 0.2 0.2 {}
T {/w3} -220 -2820 0 0 0.2 0.2 {}
T {/w4} -190 -2820 0 0 0.2 0.2 {}
T {/w0} -310 3070 0 0 0.2 0.2 {}
T {/w1} -280 3070 0 0 0.2 0.2 {}
T {/w2} -250 3070 0 0 0.2 0.2 {}
T {/w3} -220 3070 0 0 0.2 0.2 {}
T {/w4} -190 3070 0 0 0.2 0.2 {}
T {w0} -520 3070 0 0 0.2 0.2 {}
T {w1} -490 3070 0 0 0.2 0.2 {}
T {w2} -460 3070 0 0 0.2 0.2 {}
T {w3} -430 3070 0 0 0.2 0.2 {}
T {w4} -400 3070 0 0 0.2 0.2 {}
N -390 -2970 -140 -2970 {lab=w4}
N -420 -2980 -190 -2980 {lab=w3}
N -450 -2990 -240 -2990 {lab=w2}
N -480 -3000 -290 -3000 {lab=w1}
N -510 -3010 -340 -3010 {lab=w0}
N -340 -2840 -300 -2840 {lab=#net1}
N -290 -2860 -270 -2860 {lab=#net2}
N -210 -2860 -190 -2860 {lab=#net3}
N -180 -2840 -140 -2840 {lab=#net4}
N -510 2710 -510 3070 {lab=w0}
N -480 2570 -480 3070 {lab=w1}
N -450 2250 -450 3070 {lab=w2}
N -420 1570 -420 3070 {lab=w3}
N -340 -3010 -340 -2960 {lab=w0}
N -290 -3000 -290 -2960 {lab=w1}
N -240 -2990 -240 -2960 {lab=w2}
N -190 -2980 -190 -2960 {lab=w3}
N -140 -2970 -140 -2960 {lab=w4}
N -390 160 -390 3070 {lab=w4}
N -390 -3020 -390 -2970 {lab=w4}
N -420 -3020 -420 -2980 {lab=w3}
N -450 -3020 -450 -2990 {lab=w2}
N -480 -3020 -480 -3000 {lab=w1}
N -510 -3020 -510 -3010 {lab=w0}
N -180 3040 -180 3070 {lab=#net4}
N -300 2890 -300 3070 {lab=#net1}
N -340 -2880 -340 -2840 {lab=#net1}
N -290 -2880 -290 -2860 {lab=#net2}
N -270 2930 -270 3070 {lab=#net2}
N -240 2970 -240 3070 {lab=#net5}
N -210 3010 -210 3070 {lab=#net3}
N -190 -2880 -190 -2860 {lab=#net3}
N -140 -2880 -140 -2840 {lab=#net4}
N 0 2950 20 2950 {lab=#net6}
N 0 2990 20 2990 {lab=#net4}
N 0 2990 0 3040 {lab=#net4}
N 0 2770 20 2770 {lab=#net7}
N 0 2810 20 2810 {lab=#net4}
N 0 2810 0 2860 {lab=#net4}
N 0 2590 20 2590 {lab=#net8}
N 0 2630 20 2630 {lab=#net4}
N 0 2630 0 2680 {lab=#net4}
N 0 2410 20 2410 {lab=#net9}
N 0 2450 20 2450 {lab=#net4}
N 0 2450 0 2500 {lab=#net4}
N 0 2230 20 2230 {lab=#net10}
N 0 2270 20 2270 {lab=#net4}
N 0 2270 0 2320 {lab=#net4}
N 0 2050 20 2050 {lab=#net11}
N 0 2090 20 2090 {lab=#net4}
N 0 2090 0 2140 {lab=#net4}
N 0 1870 20 1870 {lab=#net12}
N 0 1910 20 1910 {lab=#net4}
N 0 1910 0 1960 {lab=#net4}
N 0 1690 20 1690 {lab=#net13}
N 0 1730 20 1730 {lab=#net4}
N 0 1730 0 1780 {lab=#net4}
N 0 1510 20 1510 {lab=#net14}
N 0 1550 20 1550 {lab=#net4}
N 0 1550 0 1600 {lab=#net4}
N 0 1330 20 1330 {lab=#net15}
N 0 1370 20 1370 {lab=#net4}
N 0 1370 0 1420 {lab=#net4}
N 0 1150 20 1150 {lab=#net16}
N 0 1190 20 1190 {lab=#net4}
N 0 1190 0 1240 {lab=#net4}
N 0 970 20 970 {lab=#net17}
N 0 1010 20 1010 {lab=#net4}
N 0 1010 0 1060 {lab=#net4}
N 0 790 20 790 {lab=#net18}
N 0 830 20 830 {lab=#net4}
N 0 830 0 880 {lab=#net4}
N 0 610 20 610 {lab=#net19}
N 0 650 20 650 {lab=#net4}
N 0 650 0 700 {lab=#net4}
N 0 430 20 430 {lab=#net20}
N 0 470 20 470 {lab=#net4}
N 0 470 0 520 {lab=#net4}
N 0 250 20 250 {lab=#net21}
N 0 290 20 290 {lab=#net4}
N 0 290 0 340 {lab=#net4}
N 0 70 20 70 {lab=#net22}
N 0 110 20 110 {lab=w4}
N 0 110 0 160 {lab=w4}
N 0 -110 20 -110 {lab=#net23}
N 0 -70 20 -70 {lab=w4}
N 0 -70 0 -20 {lab=w4}
N 0 -290 20 -290 {lab=#net24}
N 0 -250 20 -250 {lab=w4}
N 0 -250 0 -200 {lab=w4}
N 0 -470 20 -470 {lab=#net25}
N 0 -430 20 -430 {lab=w4}
N 0 -430 0 -380 {lab=w4}
N 0 -650 20 -650 {lab=#net26}
N 0 -610 20 -610 {lab=w4}
N 0 -610 0 -560 {lab=w4}
N 0 -830 20 -830 {lab=#net27}
N 0 -790 20 -790 {lab=w4}
N 0 -790 0 -740 {lab=w4}
N 0 -1010 20 -1010 {lab=#net28}
N 0 -970 20 -970 {lab=w4}
N 0 -970 0 -920 {lab=w4}
N 0 -1190 20 -1190 {lab=#net29}
N 0 -1150 20 -1150 {lab=w4}
N 0 -1150 0 -1100 {lab=w4}
N 0 -1370 20 -1370 {lab=#net30}
N 0 -1330 20 -1330 {lab=w4}
N 0 -1330 0 -1280 {lab=w4}
N 0 -1550 20 -1550 {lab=#net31}
N 0 -1510 20 -1510 {lab=w4}
N 0 -1510 0 -1460 {lab=w4}
N 0 -1730 20 -1730 {lab=#net32}
N 0 -1690 20 -1690 {lab=w4}
N 0 -1690 0 -1640 {lab=w4}
N 0 -1910 20 -1910 {lab=#net33}
N 0 -1870 20 -1870 {lab=w4}
N 0 -1870 0 -1820 {lab=w4}
N 0 -2090 20 -2090 {lab=#net34}
N 0 -2050 20 -2050 {lab=w4}
N 0 -2050 0 -2000 {lab=w4}
N 0 -2270 20 -2270 {lab=#net35}
N 0 -2230 20 -2230 {lab=w4}
N 0 -2230 0 -2180 {lab=w4}
N 0 -2450 20 -2450 {lab=#net36}
N 0 -2410 20 -2410 {lab=w4}
N 0 -2410 0 -2360 {lab=w4}
N 0 -2630 20 -2630 {lab=#net37}
N 0 -2590 20 -2590 {lab=w4}
N 0 -2590 0 -2540 {lab=w4}
N 140 -2610 180 -2610 {lab=s31}
N 140 -2430 180 -2430 {lab=s30}
N 140 -2250 180 -2250 {lab=s29}
N 140 -2070 180 -2070 {lab=s28}
N 140 -1890 180 -1890 {lab=s27}
N 140 -1710 180 -1710 {lab=s26}
N 140 -1530 180 -1530 {lab=s25}
N 140 -1350 180 -1350 {lab=s24}
N 140 -1170 180 -1170 {lab=s23}
N 140 -990 180 -990 {lab=s22}
N 140 -810 180 -810 {lab=s21}
N 140 -630 180 -630 {lab=s20}
N 140 -450 180 -450 {lab=s19}
N 140 -270 180 -270 {lab=s18}
N 140 -90 180 -90 {lab=s17}
N 140 90 180 90 {lab=s16}
N 140 270 180 270 {lab=s15}
N 140 450 180 450 {lab=s14}
N 140 630 180 630 {lab=s13}
N 140 810 180 810 {lab=s12}
N 140 990 180 990 {lab=s11}
N 140 1170 180 1170 {lab=s10}
N 140 1350 180 1350 {lab=s9}
N 140 1530 180 1530 {lab=s8}
N 140 1710 180 1710 {lab=s7}
N 140 1890 180 1890 {lab=s6}
N 140 2070 180 2070 {lab=s5}
N 140 2250 180 2250 {lab=s4}
N 140 2430 180 2430 {lab=s3}
N 140 2610 180 2610 {lab=s2}
N 140 2790 180 2790 {lab=s1}
N 140 2970 180 2970 {lab=s0}
N -300 2890 -120 2890 {lab=#net1}
N -300 2530 -300 2890 {lab=#net1}
N -270 2930 -120 2930 {lab=#net2}
N -270 2750 -270 2930 {lab=#net2}
N -240 2970 -120 2970 {lab=#net5}
N -240 2790 -240 2970 {lab=#net5}
N -210 3010 -120 3010 {lab=#net3}
N -210 2830 -210 3010 {lab=#net3}
N -180 3040 0 3040 {lab=#net4}
N -180 2860 -180 3040 {lab=#net4}
N -510 2710 -120 2710 {lab=w0}
N -510 2350 -510 2710 {lab=w0}
N -270 2750 -120 2750 {lab=#net2}
N -270 2210 -270 2750 {lab=#net2}
N -240 2790 -120 2790 {lab=#net5}
N -240 2610 -240 2790 {lab=#net5}
N -210 2830 -120 2830 {lab=#net3}
N -210 2650 -210 2830 {lab=#net3}
N -180 2860 0 2860 {lab=#net4}
N -180 2680 -180 2860 {lab=#net4}
N -300 2530 -120 2530 {lab=#net1}
N -300 2170 -300 2530 {lab=#net1}
N -480 2570 -120 2570 {lab=w1}
N -480 2390 -480 2570 {lab=w1}
N -240 2610 -120 2610 {lab=#net5}
N -240 2430 -240 2610 {lab=#net5}
N -210 2650 -120 2650 {lab=#net3}
N -210 2470 -210 2650 {lab=#net3}
N -180 2680 0 2680 {lab=#net4}
N -180 2500 -180 2680 {lab=#net4}
N -510 2350 -120 2350 {lab=w0}
N -510 1990 -510 2350 {lab=w0}
N -480 2390 -120 2390 {lab=w1}
N -480 1850 -480 2390 {lab=w1}
N -240 2430 -120 2430 {lab=#net5}
N -240 1530 -240 2430 {lab=#net5}
N -210 2470 -120 2470 {lab=#net3}
N -210 2290 -210 2470 {lab=#net3}
N -180 2500 0 2500 {lab=#net4}
N -180 2320 -180 2500 {lab=#net4}
N -300 2170 -120 2170 {lab=#net1}
N -300 1810 -300 2170 {lab=#net1}
N -270 2210 -120 2210 {lab=#net2}
N -270 2030 -270 2210 {lab=#net2}
N -450 2250 -120 2250 {lab=w2}
N -450 2070 -450 2250 {lab=w2}
N -210 2290 -120 2290 {lab=#net3}
N -210 2110 -210 2290 {lab=#net3}
N -180 2320 0 2320 {lab=#net4}
N -180 2140 -180 2320 {lab=#net4}
N -510 1990 -120 1990 {lab=w0}
N -510 1630 -510 1990 {lab=w0}
N -270 2030 -120 2030 {lab=#net2}
N -270 1490 -270 2030 {lab=#net2}
N -450 2070 -120 2070 {lab=w2}
N -450 1890 -450 2070 {lab=w2}
N -210 2110 -120 2110 {lab=#net3}
N -210 1930 -210 2110 {lab=#net3}
N -180 2140 0 2140 {lab=#net4}
N -180 1960 -180 2140 {lab=#net4}
N -300 1810 -120 1810 {lab=#net1}
N -300 1450 -300 1810 {lab=#net1}
N -480 1850 -120 1850 {lab=w1}
N -480 1670 -480 1850 {lab=w1}
N -450 1890 -120 1890 {lab=w2}
N -450 1710 -450 1890 {lab=w2}
N -210 1930 -120 1930 {lab=#net3}
N -210 1750 -210 1930 {lab=#net3}
N -180 1960 0 1960 {lab=#net4}
N -180 1780 -180 1960 {lab=#net4}
N -510 1630 -120 1630 {lab=w0}
N -510 1270 -510 1630 {lab=w0}
N -480 1670 -120 1670 {lab=w1}
N -480 1130 -480 1670 {lab=w1}
N -450 1710 -120 1710 {lab=w2}
N -450 810 -450 1710 {lab=w2}
N -210 1750 -120 1750 {lab=#net3}
N -210 130 -210 1750 {lab=#net3}
N -180 1780 0 1780 {lab=#net4}
N -180 1600 -180 1780 {lab=#net4}
N -300 1450 -120 1450 {lab=#net1}
N -300 1090 -300 1450 {lab=#net1}
N -270 1490 -120 1490 {lab=#net2}
N -270 1310 -270 1490 {lab=#net2}
N -240 1530 -120 1530 {lab=#net5}
N -240 1350 -240 1530 {lab=#net5}
N -420 1570 -120 1570 {lab=w3}
N -420 1390 -420 1570 {lab=w3}
N -180 1600 0 1600 {lab=#net4}
N -180 1420 -180 1600 {lab=#net4}
N -510 1270 -120 1270 {lab=w0}
N -510 910 -510 1270 {lab=w0}
N -270 1310 -120 1310 {lab=#net2}
N -270 770 -270 1310 {lab=#net2}
N -240 1350 -120 1350 {lab=#net5}
N -240 1170 -240 1350 {lab=#net5}
N -420 1390 -120 1390 {lab=w3}
N -420 1210 -420 1390 {lab=w3}
N -180 1420 0 1420 {lab=#net4}
N -180 1240 -180 1420 {lab=#net4}
N -300 1090 -120 1090 {lab=#net1}
N -300 730 -300 1090 {lab=#net1}
N -480 1130 -120 1130 {lab=w1}
N -480 950 -480 1130 {lab=w1}
N -240 1170 -120 1170 {lab=#net5}
N -240 990 -240 1170 {lab=#net5}
N -420 1210 -120 1210 {lab=w3}
N -420 1030 -420 1210 {lab=w3}
N -180 1240 0 1240 {lab=#net4}
N -180 1060 -180 1240 {lab=#net4}
N -510 910 -120 910 {lab=w0}
N -510 550 -510 910 {lab=w0}
N -480 950 -120 950 {lab=w1}
N -480 410 -480 950 {lab=w1}
N -240 990 -120 990 {lab=#net5}
N -240 90 -240 990 {lab=#net5}
N -420 1030 -120 1030 {lab=w3}
N -420 850 -420 1030 {lab=w3}
N -180 1060 0 1060 {lab=#net4}
N -180 880 -180 1060 {lab=#net4}
N -300 730 -120 730 {lab=#net1}
N -300 370 -300 730 {lab=#net1}
N -270 770 -120 770 {lab=#net2}
N -270 590 -270 770 {lab=#net2}
N -450 810 -120 810 {lab=w2}
N -450 630 -450 810 {lab=w2}
N -420 850 -120 850 {lab=w3}
N -420 670 -420 850 {lab=w3}
N -180 880 0 880 {lab=#net4}
N -180 700 -180 880 {lab=#net4}
N -510 550 -120 550 {lab=w0}
N -510 190 -510 550 {lab=w0}
N -270 590 -120 590 {lab=#net2}
N -270 50 -270 590 {lab=#net2}
N -450 630 -120 630 {lab=w2}
N -450 450 -450 630 {lab=w2}
N -420 670 -120 670 {lab=w3}
N -420 490 -420 670 {lab=w3}
N -180 700 0 700 {lab=#net4}
N -180 520 -180 700 {lab=#net4}
N -300 370 -120 370 {lab=#net1}
N -300 10 -300 370 {lab=#net1}
N -480 410 -120 410 {lab=w1}
N -480 230 -480 410 {lab=w1}
N -450 450 -120 450 {lab=w2}
N -450 270 -450 450 {lab=w2}
N -420 490 -120 490 {lab=w3}
N -420 310 -420 490 {lab=w3}
N -180 520 0 520 {lab=#net4}
N -180 340 -180 520 {lab=#net4}
N -510 190 -120 190 {lab=w0}
N -510 -170 -510 190 {lab=w0}
N -480 230 -120 230 {lab=w1}
N -480 -310 -480 230 {lab=w1}
N -450 -630 -450 270 {lab=w2}
N -450 270 -120 270 {lab=w2}
N -420 310 -120 310 {lab=w3}
N -420 -1310 -420 310 {lab=w3}
N -180 340 0 340 {lab=#net4}
N -180 -2840 -180 340 {lab=#net4}
N -300 10 -120 10 {lab=#net1}
N -300 -350 -300 10 {lab=#net1}
N -510 -170 -120 -170 {lab=w0}
N -510 -530 -510 -170 {lab=w0}
N -300 -350 -120 -350 {lab=#net1}
N -510 -530 -120 -530 {lab=w0}
N -300 -710 -300 -350 {lab=#net1}
N -510 -890 -510 -530 {lab=w0}
N -300 -710 -120 -710 {lab=#net1}
N -510 -890 -120 -890 {lab=w0}
N -300 -1070 -300 -710 {lab=#net1}
N -510 -1250 -510 -890 {lab=w0}
N -300 -1070 -120 -1070 {lab=#net1}
N -510 -1250 -120 -1250 {lab=w0}
N -300 -1430 -300 -1070 {lab=#net1}
N -510 -1610 -510 -1250 {lab=w0}
N -300 -1430 -120 -1430 {lab=#net1}
N -510 -1610 -120 -1610 {lab=w0}
N -300 -1790 -300 -1430 {lab=#net1}
N -510 -1970 -510 -1610 {lab=w0}
N -300 -1790 -120 -1790 {lab=#net1}
N -510 -1970 -120 -1970 {lab=w0}
N -300 -2150 -300 -1790 {lab=#net1}
N -510 -2330 -510 -1970 {lab=w0}
N -300 -2150 -120 -2150 {lab=#net1}
N -510 -2330 -120 -2330 {lab=w0}
N -300 -2510 -300 -2150 {lab=#net1}
N -510 -2690 -510 -2330 {lab=w0}
N -300 -2510 -120 -2510 {lab=#net1}
N -510 -2690 -120 -2690 {lab=w0}
N -300 -2840 -300 -2510 {lab=#net1}
N -510 -3010 -510 -2690 {lab=w0}
N -270 50 -120 50 {lab=#net2}
N -270 -130 -270 50 {lab=#net2}
N -270 -130 -120 -130 {lab=#net2}
N -270 -670 -270 -130 {lab=#net2}
N -480 -310 -120 -310 {lab=w1}
N -480 -490 -480 -310 {lab=w1}
N -480 -490 -120 -490 {lab=w1}
N -480 -1030 -480 -490 {lab=w1}
N -270 -670 -120 -670 {lab=#net2}
N -270 -850 -120 -850 {lab=#net2}
N -480 -1030 -120 -1030 {lab=w1}
N -480 -1210 -120 -1210 {lab=w1}
N -270 -850 -270 -670 {lab=#net2}
N -270 -1390 -270 -850 {lab=#net2}
N -480 -1210 -480 -1030 {lab=w1}
N -480 -1750 -480 -1210 {lab=w1}
N -270 -1390 -120 -1390 {lab=#net2}
N -270 -1570 -120 -1570 {lab=#net2}
N -480 -1750 -120 -1750 {lab=w1}
N -480 -1930 -120 -1930 {lab=w1}
N -270 -1570 -270 -1390 {lab=#net2}
N -270 -2110 -270 -1570 {lab=#net2}
N -480 -1930 -480 -1750 {lab=w1}
N -480 -2470 -480 -1930 {lab=w1}
N -270 -2110 -120 -2110 {lab=#net2}
N -270 -2290 -120 -2290 {lab=#net2}
N -480 -2470 -120 -2470 {lab=w1}
N -480 -2650 -120 -2650 {lab=w1}
N -270 -2290 -270 -2110 {lab=#net2}
N -270 -2860 -270 -2290 {lab=#net2}
N -480 -2650 -480 -2470 {lab=w1}
N -480 -3000 -480 -2650 {lab=w1}
N -240 90 -120 90 {lab=#net5}
N -240 -90 -240 90 {lab=#net5}
N -240 -90 -120 -90 {lab=#net5}
N -240 -270 -240 -90 {lab=#net5}
N -240 -270 -120 -270 {lab=#net5}
N -240 -450 -240 -270 {lab=#net5}
N -240 -450 -120 -450 {lab=#net5}
N -240 -1350 -240 -450 {lab=#net5}
N -450 -630 -120 -630 {lab=w2}
N -450 -810 -450 -630 {lab=w2}
N -450 -810 -120 -810 {lab=w2}
N -450 -990 -450 -810 {lab=w2}
N -450 -990 -120 -990 {lab=w2}
N -450 -1170 -450 -990 {lab=w2}
N -450 -1170 -120 -1170 {lab=w2}
N -450 -2070 -450 -1170 {lab=w2}
N -240 -1350 -120 -1350 {lab=#net5}
N -240 -1530 -120 -1530 {lab=#net5}
N -240 -1710 -120 -1710 {lab=#net5}
N -240 -1890 -120 -1890 {lab=#net5}
N -450 -2070 -120 -2070 {lab=w2}
N -450 -2250 -120 -2250 {lab=w2}
N -450 -2430 -120 -2430 {lab=w2}
N -450 -2610 -120 -2610 {lab=w2}
N -240 -1530 -240 -1350 {lab=#net5}
N -240 -1710 -240 -1530 {lab=#net5}
N -240 -1890 -240 -1710 {lab=#net5}
N -240 -2880 -240 -1890 {lab=#net5}
N -450 -2250 -450 -2070 {lab=w2}
N -450 -2430 -450 -2250 {lab=w2}
N -450 -2610 -450 -2430 {lab=w2}
N -450 -2990 -450 -2610 {lab=w2}
N -210 130 -120 130 {lab=#net3}
N -210 -50 -210 130 {lab=#net3}
N -210 -50 -120 -50 {lab=#net3}
N -210 -230 -210 -50 {lab=#net3}
N -210 -230 -120 -230 {lab=#net3}
N -210 -410 -210 -230 {lab=#net3}
N -210 -410 -120 -410 {lab=#net3}
N -210 -590 -210 -410 {lab=#net3}
N -210 -590 -120 -590 {lab=#net3}
N -210 -770 -210 -590 {lab=#net3}
N -210 -770 -120 -770 {lab=#net3}
N -210 -950 -210 -770 {lab=#net3}
N -210 -950 -120 -950 {lab=#net3}
N -210 -1130 -210 -950 {lab=#net3}
N -210 -1130 -120 -1130 {lab=#net3}
N -210 -2860 -210 -1130 {lab=#net3}
N -420 -1310 -120 -1310 {lab=w3}
N -420 -1490 -420 -1310 {lab=w3}
N -420 -1490 -120 -1490 {lab=w3}
N -420 -1670 -420 -1490 {lab=w3}
N -420 -1670 -120 -1670 {lab=w3}
N -420 -1850 -120 -1850 {lab=w3}
N -420 -1850 -420 -1670 {lab=w3}
N -420 -2030 -420 -1850 {lab=w3}
N -420 -2030 -120 -2030 {lab=w3}
N -420 -2210 -120 -2210 {lab=w3}
N -420 -2210 -420 -2030 {lab=w3}
N -420 -2390 -420 -2210 {lab=w3}
N -420 -2390 -120 -2390 {lab=w3}
N -420 -2570 -120 -2570 {lab=w3}
N -420 -2570 -420 -2390 {lab=w3}
N -420 -2980 -420 -2570 {lab=w3}
N -390 -2540 0 -2540 {lab=w4}
N -390 -2970 -390 -2540 {lab=w4}
N -390 -2180 0 -2180 {lab=w4}
N -390 -2360 -390 -2180 {lab=w4}
N -390 -2000 0 -2000 {lab=w4}
N -390 -2180 -390 -2000 {lab=w4}
N -390 -1820 0 -1820 {lab=w4}
N -390 -2000 -390 -1820 {lab=w4}
N -390 -1640 0 -1640 {lab=w4}
N -390 -1820 -390 -1640 {lab=w4}
N -390 -1460 0 -1460 {lab=w4}
N -390 -1640 -390 -1460 {lab=w4}
N -390 -1280 0 -1280 {lab=w4}
N -390 -1460 -390 -1280 {lab=w4}
N -390 -1100 0 -1100 {lab=w4}
N -390 -1280 -390 -1100 {lab=w4}
N -390 -920 0 -920 {lab=w4}
N -390 -1100 -390 -920 {lab=w4}
N -390 -740 0 -740 {lab=w4}
N -390 -920 -390 -740 {lab=w4}
N -390 -560 0 -560 {lab=w4}
N -390 -740 -390 -560 {lab=w4}
N -390 -380 0 -380 {lab=w4}
N -390 -560 -390 -380 {lab=w4}
N -390 -200 0 -200 {lab=w4}
N -390 -380 -390 -200 {lab=w4}
N -390 -20 0 -20 {lab=w4}
N -390 -200 -390 -20 {lab=w4}
N -390 160 0 160 {lab=w4}
N -390 -20 -390 160 {lab=w4}
N -390 -2360 0 -2360 {lab=w4}
N -390 -2540 -390 -2360 {lab=w4}
N 100 -2910 150 -2910 {lab=VDD}
N 100 -2890 150 -2890 {lab=VSS}
C {opin.sym} 180 2430 0 0 {name=p5 lab=s3}
C {opin.sym} 180 2970 0 0 {name=p6 lab=s0}
C {opin.sym} 180 2790 0 0 {name=p7 lab=s1}
C {opin.sym} 180 2610 0 0 {name=p8 lab=s2}
C {opin.sym} 180 2250 0 0 {name=p9 lab=s4}
C {opin.sym} 180 2070 0 0 {name=p10 lab=s5}
C {opin.sym} 180 1350 0 0 {name=p11 lab=s9}
C {opin.sym} 180 1890 0 0 {name=p12 lab=s6}
C {opin.sym} 180 1710 0 0 {name=p13 lab=s7}
C {opin.sym} 180 1530 0 0 {name=p14 lab=s8}
C {opin.sym} 180 1170 0 0 {name=p15 lab=s10}
C {opin.sym} 180 990 0 0 {name=p16 lab=s11}
C {opin.sym} 180 270 0 0 {name=p17 lab=s15}
C {opin.sym} 180 810 0 0 {name=p18 lab=s12}
C {opin.sym} 180 630 0 0 {name=p19 lab=s13}
C {opin.sym} 180 450 0 0 {name=p20 lab=s14}
C {opin.sym} 180 90 0 0 {name=p21 lab=s16}
C {opin.sym} 180 -90 0 0 {name=p22 lab=s17}
C {opin.sym} 180 -810 0 0 {name=p23 lab=s21}
C {opin.sym} 180 -270 0 0 {name=p24 lab=s18}
C {opin.sym} 180 -450 0 0 {name=p25 lab=s19}
C {opin.sym} 180 -630 0 0 {name=p26 lab=s20}
C {opin.sym} 180 -990 0 0 {name=p27 lab=s22}
C {opin.sym} 180 -1170 0 0 {name=p28 lab=s23}
C {opin.sym} 180 -1350 0 0 {name=p29 lab=s24}
C {opin.sym} 180 -1530 0 0 {name=p30 lab=s25}
C {opin.sym} 180 -2250 0 0 {name=p31 lab=s29}
C {opin.sym} 180 -1710 0 0 {name=p32 lab=s26}
C {opin.sym} 180 -1890 0 0 {name=p33 lab=s27}
C {opin.sym} 180 -2070 0 0 {name=p34 lab=s28}
C {opin.sym} 180 -2430 0 0 {name=p35 lab=s30}
C {opin.sym} 180 -2610 0 0 {name=p36 lab=s31}
C {ipin.sym} -390 -3020 1 0 {name=p37 lab=w4}
C {ipin.sym} -420 -3020 1 0 {name=p38 lab=w3}
C {ipin.sym} -450 -3020 1 0 {name=p39 lab=w2}
C {ipin.sym} -480 -3020 1 0 {name=p40 lab=w1}
C {ipin.sym} -510 -3020 1 0 {name=p41 lab=w0
}
C {sg13g2_stdcells/sg13g2_inv_1.sym} -340 -2920 1 0 {name=x1 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} -290 -2920 1 0 {name=x2 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} -240 -2920 1 0 {name=x3 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} -190 -2920 1 0 {name=x4 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_inv_1.sym} -140 -2920 1 0 {name=x5 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 2950 0 0 {name=x7 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 2970 0 0 {name=x8 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 2770 0 0 {name=x9 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 2790 0 0 {name=x10 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 2590 0 0 {name=x11 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 2610 0 0 {name=x12 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 2410 0 0 {name=x13 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 2430 0 0 {name=x14 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 2230 0 0 {name=x15 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 2250 0 0 {name=x16 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 2050 0 0 {name=x17 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 2070 0 0 {name=x18 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 1870 0 0 {name=x19 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 1890 0 0 {name=x20 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 1690 0 0 {name=x21 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 1710 0 0 {name=x22 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 1510 0 0 {name=x23 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 1530 0 0 {name=x24 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 1330 0 0 {name=x25 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 1350 0 0 {name=x26 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 1150 0 0 {name=x27 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 1170 0 0 {name=x28 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 970 0 0 {name=x29 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 990 0 0 {name=x30 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 790 0 0 {name=x31 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 810 0 0 {name=x32 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 610 0 0 {name=x33 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 630 0 0 {name=x34 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 430 0 0 {name=x35 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 450 0 0 {name=x36 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 250 0 0 {name=x37 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 270 0 0 {name=x38 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 70 0 0 {name=x39 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 90 0 0 {name=x40 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 -110 0 0 {name=x41 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 -90 0 0 {name=x42 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 -290 0 0 {name=x43 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 -270 0 0 {name=x44 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 -470 0 0 {name=x45 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 -450 0 0 {name=x46 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 -650 0 0 {name=x47 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 -630 0 0 {name=x48 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 -830 0 0 {name=x49 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 -810 0 0 {name=x50 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 -1010 0 0 {name=x51 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 -990 0 0 {name=x52 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 -1190 0 0 {name=x53 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 -1170 0 0 {name=x54 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 -1370 0 0 {name=x55 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 -1350 0 0 {name=x56 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 -1550 0 0 {name=x57 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 -1530 0 0 {name=x58 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 -1730 0 0 {name=x59 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 -1710 0 0 {name=x60 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 -1910 0 0 {name=x61 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 -1890 0 0 {name=x62 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 -2090 0 0 {name=x63 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 -2070 0 0 {name=x64 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 -2270 0 0 {name=x65 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 -2250 0 0 {name=x66 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 -2450 0 0 {name=x67 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 -2430 0 0 {name=x68 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and4_1.sym} -60 -2630 0 0 {name=x69 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {sg13g2_stdcells/sg13g2_and2_1.sym} 80 -2610 0 0 {name=x70 VDD=VDD VSS=VSS prefix=sg13g2_ }
C {lab_pin.sym} 150 -2910 2 0 {name=p3 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 150 -2890 2 0 {name=p4 sig_type=std_logic lab=VSS}
C {ipin.sym} 100 -2910 0 0 {name=p42 lab=VDD}
C {ipin.sym} 100 -2890 0 0 {name=p1 lab=VSS}
